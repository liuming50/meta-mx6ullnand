IMAGE_INSTALL:append = " \
    mtd-utils \
    u-boot-imx-env \
"
