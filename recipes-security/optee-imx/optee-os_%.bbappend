
COMPATIBLE_MACHINE = "(mx6ull|mx6ull-c-q|mx6-generic-bsp)"
